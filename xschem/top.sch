v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
N 30 -150 95 -150 {}
N 185 -150 260 -150 {}
C {devices/iopin.sym} -150 -80 0 0 {name=p1 lab=VDD}
C {devices/iopin.sym} -150 -60 0 0 {name=p2 lab=VSS}
C {devices/ipin.sym} 70 -200 0 0 {name=p3 lab=IN}
C {devices/opin.sym} 260 -200 0 0 {name=p4 lab=OUT}
C {inverter.sym} 130 -150 0 0 {name=x1[99:0]}
